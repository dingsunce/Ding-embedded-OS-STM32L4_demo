# IAR project xKnxStack.ewp, settings and files
configuration demo_free_rtos (ARM, debug)
  General.OGChipSelectEditMenu: STM32L462CE ST STM32L462CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32L462xx; _WIZCHIP_=5100; FUNTION_STATE_DEFINE=1; STM32_SERIAL_L4; AT24C256; OS_TYPE=3; OS_INVERTED_PRIORITY=1
  ICCARM.CCIncludePath2: ../Core/Inc; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../../OS/DING_OS; ../../OS/OSAL/free_rtos; ../../OS/PREEAMPTIVE_OS/free_rtos/include; ../../OS/PREEAMPTIVE_OS/free_rtos/portable/IAR/ARM_CM4F; ../../App; ../../App/Common; ../../App/free_rtos_app; ../../Lib/bsp/common; ../../Lib/bsp/stm32_ll
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../App/free_rtos_app
  OBJCOPY.OOCOutputFile: KnxTpSystemB.hex
  ILINK.IlinkOutputFile: KnxTpSystemB.out
  ILINK.IlinkIcfFile: xKnxStack.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration demo_rt_thread (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32L462xx; FUNTION_STATE_DEFINE=1; STM32_SERIAL_L4; AT24C256; OS_TYPE=2
  ICCARM.CCIncludePath2: ../Core/Inc; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../../OS/DING_OS; ../../OS/OSAL/rt_thread; ../../OS/PREEAMPTIVE_OS/rt_thread/include; ../../App; ../../App/Common; ../../App/rt_thread_app; ../../Lib/bsp/common; ../../Lib/bsp/stm32_ll
configuration demo_ucos (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32L462xx; FUNTION_STATE_DEFINE=1; STM32_SERIAL_L4; AT24C256; OS_TYPE=1
  ICCARM.CCIncludePath2: ../Core/Inc; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../../OS/DING_OS; ../../OS/OSAL/ucos; ../../OS/PREEAMPTIVE_OS/ucos/uC-CPU; ../../OS/PREEAMPTIVE_OS/ucos/uC-CPU/ARM-Cortex-M/ARMv7-M\IAR; ../../OS/PREEAMPTIVE_OS/ucos/uC-LIB; ../../OS/PREEAMPTIVE_OS/ucos/uC-LIB/Ports/ARM-Cortex-M4/IAR; ../../OS/PREEAMPTIVE_OS/ucos/uCOS-III; ../../OS/PREEAMPTIVE_OS/ucos/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR; ../../OS/PREEAMPTIVE_OS/ucos/UCOS_BSP_STM32L4; ../../App; ../../App/Common; ../../App/uccos_app; ../../Lib/bsp/common; ../../Lib/bsp/stm32_ll
configuration demo_non_preemptive (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32L462xx; FUNTION_STATE_DEFINE=1; STM32_SERIAL_L4; AT24C256
  ICCARM.CCIncludePath2: ../Core/Inc; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../../OS/DING_OS; ../../OS/OSAL\non_preemptive_os; ../../App; ../../App/Common; ../../Lib/bsp/common; ../../Lib/bsp/stm32_ll
  group APP
    ../../App/: Project.h
  group APP/Common
    ../../App/Common/: app_ipc_test.c app_ipc_test.h app_msg_test.c app_msg_test.h hw_config.c hw_config.h
  group APP/free_rtos_app
    ../../App/free_rtos_app/: board.c FreeRTOSConfig.h
  group APP/non_preemptive_os_app
    ../../App/non_preemptive_os_app/: board.c
  group APP/rt_thread_app
    ../../App/rt_thread_app/: board.c rtconfig.h
  group APP/uccos_app
    ../../App/uccos_app/: board.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h os_cfg_app.h
  group Application/EWARM
    ./: startup_stm32l462xx.s
  group Application/User/Core
    ../Core/Src/: aes.c dma.c gpio.c i2c.c iwdg.c main.c rtc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c tim.c usart.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_custom_hid_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rtc.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
  group Lib/bsp/common
    ../../Lib/bsp/common/: adc_func.h assert_func.h clock_func.h debug_func.h delay_func.h eeprom_func.h flash_func.h func.h i2c_func.h interrupt_func.h io_func.h ir_rx_func.h ir_tx_func.h pwm_func.h random_func.h reset_func.h rtc_func.h sleep_func.h tcp_func.h tick_func.h uart_func.h unique_id_func.h usb_custom_hid_func.h wdg_func.h
  group Lib/bsp/stm32_ll
    ../../Lib/bsp/stm32_ll/: stm32ll.h stm32ll_adc.c stm32ll_assert.c stm32ll_external_eeprom.c stm32ll_i2c.c stm32ll_i2c_impl.c stm32ll_i2c_impl.h stm32ll_interrupt.c stm32ll_io.c stm32ll_reset.c stm32ll_sleep.c stm32ll_unique_id.c stm32ll_usb_custom_hid_func.c stm32ll_usb_custom_hid_func.h stm32ll_wdg.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group OS/DING_OS
    ../../OS/DING_OS/: d_mem.c d_mem.h d_os.c d_os.h d_task.c d_task.h define.h DList.c DList.h error.h lc-switch.h memb.c memb.h message.c message.h process.c process.h pt.h s_list.c s_list.h SList.c SList.h SysTick.c SysTick.h
  group OS/OSAL/free_rtos
    ../../OS/OSAL/free_rtos/: osal.c osal.h
  group OS/OSAL/non_preemptive_os
    ../../OS/OSAL/non_preemptive_os/: osal.c osal.h
  group OS/OSAL/rt_thread
    ../../OS/OSAL/rt_thread/: osal.c osal.h
  group OS/OSAL/ucos
    ../../OS/OSAL/ucos/: osal.c osal.h
  group OS/PREEAMPTIVE_OS/free_rtos
    ../../OS/PREEAMPTIVE_OS/free_rtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group OS/PREEAMPTIVE_OS/free_rtos/include
    ../../OS/PREEAMPTIVE_OS/free_rtos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h task.h timers.h
  group OS/PREEAMPTIVE_OS/free_rtos/MemMang
    ../../OS/PREEAMPTIVE_OS/free_rtos/MemMang/: heap_2.c
  group OS/PREEAMPTIVE_OS/free_rtos/portable
    ../../OS/PREEAMPTIVE_OS/free_rtos/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group OS/PREEAMPTIVE_OS/rt_thread/include
    ../../OS/PREEAMPTIVE_OS/rt_thread/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtm.h rtservice.h rtthread.h
  group OS/PREEAMPTIVE_OS/rt_thread/libcpu/cortex-m4
    ../../OS/PREEAMPTIVE_OS/rt_thread/libcpu/cortex-m4/: context_iar.S cpuport.c
  group OS/PREEAMPTIVE_OS/rt_thread/src
    ../../OS/PREEAMPTIVE_OS/rt_thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group OS/PREEAMPTIVE_OS/ucos/uC-CPU
    ../../OS/PREEAMPTIVE_OS/ucos/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group OS/PREEAMPTIVE_OS/ucos/uC-CPU/Ports
    ../../OS/PREEAMPTIVE_OS/ucos/uC-CPU/ARM-Cortex-M/ARMv7-M/IAR/: cpu.h cpu_a.asm
    ../../OS/PREEAMPTIVE_OS/ucos/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
  group OS/PREEAMPTIVE_OS/ucos/uC-LIB
    ../../OS/PREEAMPTIVE_OS/ucos/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group OS/PREEAMPTIVE_OS/ucos/uCOS-III
    ../../OS/PREEAMPTIVE_OS/ucos/uCOS-III/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group OS/PREEAMPTIVE_OS/ucos/uCOS-III/Ports
    ../../OS/PREEAMPTIVE_OS/ucos/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm
    ../../OS/PREEAMPTIVE_OS/ucos/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
  group OS/PREEAMPTIVE_OS/ucos/UCOS_BSP_STM32L4
    ../../OS/PREEAMPTIVE_OS/ucos/UCOS_BSP_STM32L4/: bsp.c bsp.h bsp_int.c cpu_bsp.c cstartup.c
